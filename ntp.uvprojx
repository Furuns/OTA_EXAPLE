# Keil uVision project ntp.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ntp +hex
  AfterMake: fromelf.exe --bin --output ./output/ntp.bin ./output/ntp.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\User;.\system;.\flib\inc;.\flib\src;.\output;.\word\24c02;.\word\device;.\word\md5;.\word\socket;.\word\spi;.\word\ult;.\word\w5500;.\word\ntp;.\word\usart;.\word;.\word\dns;.\my_device_info;.\mqtt_fun;.\Link Kit SDK3.0.1;.\Link Kit SDK3.0.1\ota;.\Link Kit SDK3.0.1\certs;.\Link Kit SDK3.0.1\external\mbedtls\include;.\Link Kit SDK3.0.1\external\tls;.\Link Kit SDK3.0.1\infra;.\Link Kit SDK3.0.1\wrappers;.\Link Kit SDK3.0.1\dev_sign;.\Link Kit SDK3.0.1\mqtt;.\Link Kit SDK3.0.1\external\mbedtls\include\mbedtls;.\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h types.h
  group system
    ./system/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group flib
    ./flib/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group word
    ./word/device/: device.c device.h
    ./word/md5/: md5.c md5.h
    ./word/socket/: socket.c socket.h
    ./word/spi/: spi2.c spi2.h
    ./word/ult/: ult.c ult.h
    ./word/w5500/: w5500.c w5500.h
    ./word/ntp/: ntp.h
    ./word/usart/: usart.c usart.h
    ./word/: sha1.c timer.c tcp_client.c
    ./word/dns/: dns.c
  group certs
    ./Link Kit SDK3.0.1/certs/: root_ca.c
  group dev_sign
    ./Link Kit SDK3.0.1/dev_sign/: dev_sign_mqtt.c
  group infra
    ./Link Kit SDK3.0.1/infra/: infra_compat.c infra_defs.c infra_httpc.c infra_json_parser.c infra_md5.c infra_net.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
  group mqtt
    ./Link Kit SDK3.0.1/mqtt/: iotx_mqtt_client.c mqtt_api.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group ota
    ./Link Kit SDK3.0.1/ota/: iotx_ota.c ota_coap.c ota_fetch.c ota_lib.c ota_mqtt.c
  group wrappers
    ./Link Kit SDK3.0.1/wrappers/: wrapper.c
  group aliyun
    ./my_device_info/: my_device_info.c
    ./Link Kit SDK3.0.1/: ota_example_mqtt.c
  group extern_tls
    ./Link Kit SDK3.0.1/external/tls/: HAL_TLS_mbedtls.c
  group mbedtls
    ./Link Kit SDK3.0.1/external/mbedtls/library/: aes.c asn1parse.c base64.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c entropy.c entropy_poll.c error.c md.c md_wrap.c net_sockets.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c rsa.c sha1.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_tls.c timing.c x509.c x509_crt.c md5.c
software components: CMSIS:CORE 5.2.0
